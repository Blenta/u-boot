// SPDX-License-Identifier: GPL-2.0+
/*
 * Samsung's Exynos4412 based Tiny4412 board device tree source
 *
 * Copyright (c) 2014 Samsung Electronics Co., Ltd.
 *		http://www.samsung.com
 */

/dts-v1/;
#include "skeleton.dtsi"
#include "exynos4412.dtsi"

/ {
	model = "Tiny4412(v1412) board based on Exynos4412";
	compatible = "samsung,tiny4412", "samsung,exynos4412";

	chosen {
		bootargs ="root=/dev/mmcblk0p1 rootfstype=ext4 console=ttySAC0,115200 init=/linuxrc ctp=2 skipcali=y";
	};

	config {

		/* 
		* sd_env_offset = 512 + 8*1024 + 16*1024 + 800*1024
		* emmc_env_offset = sd_env_offset - 512
		* kernel-offset = 512 + 8*1024 + 16*1024*2 + 800*1024
		*/
		u-boot,sd-env-offset = <0xCE200>;
		u-boot,emmc-env-offset = <0xCE000>;
		bootcmd = "
		if mmc rescan; then \
			echo SD/MMC found on device ${mmcbootdev}; \
			if test ${mmcbootdev} = 2; then \
				if mmc dev ${mmcbootdev}; then \
					echo read zImage from SD card...; \
					mmc read ${kerneladdr} ${sdkernelboff} ${kernelbsize}; \
				fi; \
			else \
				if mmc dev 0 0; then \
					echo read zImage from eMMC card...; \
					mmc read ${kerneladdr} ${eMMCkernelboff} ${kernelbsize}; \
				fi; \
			fi; \
		fi; \
		bootz ${loadaddr} ";
	};


	aliases {
		mmc0 = &sdhci0;
		mmc2 = &sdhci2;
		serial0 = "/serial@13800000";
		console = "/serial@13800000";
	};
};


&sdhci0 {
	bus-width = <4>;
	samsung,timing = <1 2 3>;
	cap-mmc-highspeed = "true";
	non-removable = "true";
	status = "okay";
};


&sdhci2 {
	bus-width = <4>;
	samsung,timing = <1 2 3>;
	cd-gpios = <&gpk2 2 0>;
	cap-sd-highspeed = "true";
	cd-inverted = "true";
	status = "okay";
};
